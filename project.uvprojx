# Keil uVision project project.uvprojx, settings and files
target rtthread (6190000::V6.19::ARMCLANG)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.17.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x018000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, MCUXPRESSO_SDK, RT_USING_ARMLIBC, SKIP_SYSCLK_INIT, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, __RTTHREAD__, CPU_MIMXRT1052CVL5B, XIP_EXTERNAL_FLASH=1, EVK_MCIMXRM, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, DEBUG, CPU_MIMXRT1052DVL6B, BSP_USING_HYPERFLASH
  c misc: -ffunction-sections -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb -Wno-invalid-source-encoding
  c include: rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include;xxx\board\MCUX_Config;rt-thread\components\libc\posix\io\eventfd;rt-thread\libcpu\arm\common;libraries\MIMXRT1050\CMSIS\Include;rt-thread\components\drivers\include;.;board;rt-thread\components\libc\posix\io\epoll;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\compilers\common\extension;rt-thread\components\finsh;rt-thread\components\libc\compilers\common\include;xxx\applications;libraries\MIMXRT1050\MIMXRT1052;libraries\MIMXRT1050\MIMXRT1052\drivers;board\ports;rt-thread\include;xxx\board;rt-thread\components\drivers\include;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\include;board\MCUX_Config;applications;xxx\board\ports;libraries\drivers;.\board\xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: .
  memory RVCT4: ROM 0x200000 size 0x18000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --remove --entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
--remove
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c
    libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/MIMXRT1050/MIMXRT1052/: system_MIMXRT1052.c
    libraries/MIMXRT1050/MIMXRT1052/drivers/: generic_list.c fsl_gpio.c fsl_lpuart.c fsl_clock.c fsl_xbarb.c fsl_cache.c fsl_common.c fsl_xbara.c fsl_os_abstraction_rtthread.c
    libraries/MIMXRT1050/MIMXRT1052/arm/: startup_MIMXRT1052.s
    ./libraries/xip/: evkbimxrt1050_flexspi_nor_config.c fsl_flexspi_nor_boot.c
